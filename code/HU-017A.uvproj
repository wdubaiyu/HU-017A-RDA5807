# Keil uVision project HU-017A.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: HU-017A +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h
    ./config/: Config.c Config.h EEPROM.c EEPROM.h
    ./rda5807/: I2C.c I2C.h RDA5807M.c RDA5807M.h
    ./led/: 74HC595.c 74HC595.h myLed.c myLed.h
    ./key/: Key.c Key.h
    ./time/: time0.c time0.h time2.c time2.h
